# Keil uVision project freertos_cubemx.uvprojx, settings and files
target freertos_cubemx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: freertos_cubemx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;                ../Drivers/STM32F1xx_HAL_Driver/Inc;                ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                ../Middlewares/Third_Party/FreeRTOS/Source/include;                ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                ../Drivers/CMSIS/Include;                ..\Middlewares\Third_Party\STemWin;                ..\Middlewares\Third_Party\STemWin\config\inc;                ..\Middlewares\Third_Party\STemWin\config\src;                ..\Middlewares\Third_Party\STemWin\config;                ..\Middlewares\Third_Party\STemWin\lib;                ..\Middlewares\Third_Party\STemWin\lib\inc;                ..\Middlewares\Third_Party\STemWin\lib\src
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: lcdcmd.c touch.c sram.c arrow.c Arial18.c Digital-7 Mono70.c skinning.c Arial16.c button76x76Skin.c guivars.c callbacks.c main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group GUI
    ../Middlewares/Third_Party/STemWin/config/src/: GUIConf.c GUIDRV_Template.c LCDConf.c WindowDLG.c mainMenu.c LineSetup.c LineSetupPulse.c Password.c TimeCalibrate.c TimeDateSetup.c TimeSetup.c TimeSumWinSetup.c
    ../Middlewares/Third_Party/STemWin/lib/src/: GUI_X_OS.c
    ../Middlewares/Third_Party/STemWin/lib/: STemWin532_CM3_OS_Keil.lib
software components: CMSIS:CORE 4.3.0
